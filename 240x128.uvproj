# Keil uVision project 240x128.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: S1S2水瓶带水位检测水雕上板程序170701 +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 240x128.C key.c
